ORG 0H
BUTTON:	JB P1.0,BUTTON
MOV TMOD, #01H
MOV TH0,#00Fh
MOV TL0,#00Fh
ANA:
SETB TR0
MOV R3,#0DH
MOV R4,#0DH
	 BEKLE: JNB TF0,AD
	 CLR TF0 ;BURADA DISPLAY ÇALIÞIRKEN 1 SANIYE
	 DJNZ R4,BEKLE
SJMP DEVAM
AD:  CPL P3.4
	CLR P1.1
	CLR P1.2
	CLR P1.6
	CLR P2.3	 
	SETB P2.3
	MOV P1,#0FFH
	CLR P1.2
	CLR P1.7
	CLR P2.2
	SETB P2.2
	MOV P1,#0FFH
	CLR P1.3
	CLR P1.6
	CLR P2.1
	SETB P2.1
	MOV P1,#0FFH
	CLR P1.6
	CLR P2.0
	SETB P2.0
	MOV P1,#0FFH
	SJMP BEKLE
DEVAM: JNB TF0,DEVAM
CLR TF0 ; BURADA DISPLAY KAPALI ÝKEN 1 SANÝYE BEKLEME
CPL P3.5
DJNZ R3,DEVAM
SJMP ANA