ORG 0H
BUTTON:	JB P1.0,BUTTON
SJMP ANA
ANA: MOV TMOD, #01H
MOV TH0,#00Fh
MOV TL0,#00Fh
SETB TR0
DEVAM:
MOV R3,#0FH
MOV R4,#0FH
DONGU: 
BEKLE: JNB TF0,BEKLE
CLR TF0 ; BURADA DISPLAY KAPALI ÝKEN 1 SANÝYE BEKLEME
CPL P3.5
DJNZ R3,DONGU

AD:   	
CPL P3.4
	CLR P1.1
	CLR P1.2
	CLR P1.6
	CLR P2.3	 
	SETB P2.3
	MOV P1,#0ffh
	SJMP SOYAD
SOYAD: 	
	CLR P1.2
	CLR P1.7
	CLR P2.2
	SETB P2.2
	MOV P1,#0ffh
	SJMP OGRENIM
OGRENIM:   	
	CLR P1.3
	CLR P1.6
	CLR P2.1
	SETB P2.1
	MOV P1,#0ffh
	SJMP GRUP
GRUP: 	
	CLR P1.6
	CLR P2.0
	SETB P2.0
	MOV P1,#0ffh
SJMP BEKLE2
	 DONGU1: 
	 BEKLE2: JNB TF0,AD
	 CLR TF0 ;BURADA DISPLAY ÇALIÞIRKEN 1 SANIYE
	 DJNZ R4,DONGU1
	 SJMP DEVAM
